# Keil uVision project CWM_nrf52840.uvprojx, settings and files
target IK-52840DK (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: nrf52840_qiaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10056 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192 PLATFORM_NORDIC NRF_CLOCK_ENABLED APP_TIMER_ENABLED NRFX_CLOCK_ENABLED
  c misc: --reduce_paths
  c include: ..\config;..\..\components;..\..\components\boards;..\..\modules\nrfx;..\..\modules\nrfx\hal;..\..\modules\nrfx\mdk;..\..\modules\nrfx\drivers\include;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\components\drivers_nrf\nrf_soc_nosd;..\..\components\libraries\delay;..\..\components\libraries\util;..\..\components\libraries\strerror;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\memobj;..\..\components\libraries\balloc;..\..\components\libraries\ringbuf;..\..\components\libraries\atomic;..\..\components\libraries\uart;..\..\components\libraries\fifo;..\..\external\fprintf;..\..\external\segger_rtt;..\..\app\w25q128;..\..\CWM_Release\Library\Inc;..\..\app;..\..\app\icm_42607\app\example_raw;..\..\app\icm_42607\app\system_interface;..\..\app\icm_42607\common\Invn\EmbUtils;..\..\app\icm_42607\common;..\..\app\icm_42607\drivers\imu;..\..\app\icm_42607\drivers;..\..\app\icm_42607\port;..\..\components\libraries\timer;..\..\app\lsm6dsow
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../../app/: main.c board_nordic.c config.h sensor_init.c cwm_lib_api.c
    ../config/: sdk_config.h
    ../../app/w25q128/: w25q128.c
  group Board Definition
    ../../components/boards/: boards.c
  group nRF_Drivers
    ../../integration/nrfx/legacy/: nrf_drv_spi.c nrf_drv_clock.c nrf_drv_uart.c nrf_drv_twi.c
    ../../modules/nrfx/soc/: nrfx_atomic.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../modules/nrfx/drivers/src/: nrfx_uart.c nrfx_uarte.c nrfx_spi.c nrfx_spim.c nrfx_clock.c nrfx_gpiote.c nrfx_rtc.c nrfx_timer.c nrfx_twi.c nrfx_twim.c nrfx_systick.c nrfx_power_clock.c
  group nRF_Libraries
    ../../components/libraries/util/: app_error.c nrf_assert.c app_util_platform.c app_error_handler_keil.c app_error_weak.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../components/libraries/memobj/: nrf_memobj.c
    ../../components/libraries/atomic/: nrf_atomic.c
    ../../components/libraries/balloc/: nrf_balloc.c
    ../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../components/libraries/fifo/: app_fifo.c
    ../../components/libraries/timer/: app_timer.c
  group nRF_Log
    ../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group lib
    ../../CWM_Release/Library/Lib/: CWM_LIB_Keil_m4.lib
  group ICM_42607
    ../../app/icm_42607/drivers/imu/: inv_imu_apex.c inv_imu_driver.c inv_imu_selftest.c inv_imu_transport.c
    ../../app/icm_42607/app/example_raw/: example_raw.c
    ../../app/icm_42607/app/system_interface/: system_interface.c
    ../../app/icm_42607/common/Invn/EmbUtils/: DataConverter.c ErrorHelper.c InvBasicMath.c Message.c RingByteBuffer.c
    ../../app/icm_42607/port/: icm_42607_port.c
  group LSM6DSOW
    ../../app/lsm6dsow/: lsm6dso_reg.c
software components: CMSIS:CORE 5.3.0, Device:Startup 8.35.0
